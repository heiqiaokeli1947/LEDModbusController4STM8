# IAR project RelayCtrl.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RelayCtrl.hex
  ILINK.IlinkOutputFile: RelayCtrl.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group CfgParam
    Flash/: CfgParam.c CfgParam.h FLASH.c FLASH.h
  group Interrupt
    Interrupt/: int.c int.h
  group IO
    IO/: GPIO.c GPIO.h
  group Modbus
    Modbus/: crc16.c crc16.h Modbus.c Modbus.h ModbusDeal.c ModbusDeal.h
  group Wdg
    Wdg/: Wdg.c Wdg.h
